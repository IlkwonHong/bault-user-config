/ {
    /* 소프트오프 중 '아무 키'로 깨우기 */
    soft_off_wakers {
        compatible = "zmk,soft-off-wakeup-sources";
        wakeup-sources = <&kscan0>;
    };
};

&kscan0 {
    wakeup-source;
};
